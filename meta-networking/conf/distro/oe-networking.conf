## meta-networking/conf/distro/poky-networking.conf
```bitbake
require conf/distro/poky.conf

DISTRO = "poky-networking"
DISTROOVERRIDES = "poky:networking"
```
